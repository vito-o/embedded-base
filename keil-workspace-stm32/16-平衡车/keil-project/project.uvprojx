# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\App;.\Com;.\Dri;.\Int;.\Mid\FreeRTOS;.\Mid\FreeRTOS\Source;.\Mid\FreeRTOS\Portable;.\Mid\FreeRTOS\include;.\Start;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Mid/FreeRTOS
    ./Mid/FreeRTOS/: FreeRTOSConfig.h
  group Mid/FreeRTOS/Source
    ./Mid/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Mid/FreeRTOS/Portable
    ./Mid/FreeRTOS/Portable/: heap_4.c port.c portmacro.h
  group User
    ./User/: main.c
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
