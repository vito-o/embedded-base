# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Start;.\User;.\Hardware\led;.\Hardware\key;.\Hardware\tim;.\Hardware\usart;.\Hardware\i2c;.\Hardware\w24c02
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c delay.c delay.h Systick.c Systick.h
  group Hardware/led
    ./Hardware/led/: led.c led.h
  group Hardware/key
    ./Hardware/key/: Key.c
  group Hardware/usart
    ./Hardware/usart/: Usart.c Usart.h
  group Hardware/i2c
    ./Hardware/i2c/: i2c.c i2c.h
  group Hardware/w24c02
    ./Hardware/w24c02/: w24c02.c w24c02.h
