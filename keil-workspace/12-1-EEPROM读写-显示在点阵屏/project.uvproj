# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Dri_IIC.c Dri_IIC.h Int_EEPROM.c Int_EEPROM.h Delay.c Delay.h MatrixLED.c MatrixLED.h
