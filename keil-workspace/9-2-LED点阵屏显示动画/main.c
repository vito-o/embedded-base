#include <REGX52.H>
#include "MatrixLED.h"
//unsigned char Animation[] 这里的数据会放在ram中，存储较小，可以放到flash中，使用方式unsigned char code Animation[] 加个code就可以了
//当然flash中的数据只能读取不能更改
unsigned char code Animation[] = {
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
	0xFF,0x08,0x08,0x08,0xFF,0x00,0x0E,0x15,0x15,0x15,0x08,0x00,0x7E,0x01,0x02,0x00,
	0x7E,0x01,0x02,0x00,0x0E,0x11,0x11,0x0E,0x00,0x7D,0x00,0x00,0x00,0x00,0x00,0x00,
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};

unsigned char i, offset = 0, cout = 0;

void main()
{
		MatrixLED_init();
			
		while(1)
		{
			for(i=0;i<8;i++)
			{
				MatrixLED_ShowColIndex(i, Animation[i+offset]);	
			}
			cout++;
			
			if(cout > 10)
			{
				cout = 0;
				offset++;
				if (offset > 40) 
				{
					offset = 0;
				}
			}
		}
}